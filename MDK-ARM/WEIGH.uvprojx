# Keil uVision project WEIGH.uvprojx, settings and files
target WEIGH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: weigh_dev +hex
  AfterMake: fromelf.exe --bin --output ./bin/bufei_app.bin ./weigh_obj/weigh_dev.axf
  AfterMake: .\bin\mcu_tools.exe  ./../Inc/board_info.h  bufei_app.bin
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Application\inc;..\event_manage\inc;..\Hardware\inc;..\iap_boot\inc;..\uart_debug\inc;..\Switch;..\Hardware\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group switch
    ../Switch/: HwIOConfig.h SwitchConfig.h
  group application
    ../Application/src/: application.c interface.c command.c RC663.C nfc_interface.c FM176XX.c MIFARE.c READER_API.c
  group iap_boot
    ../iap_boot/src/: st_flash.c frame_parse.c ex_flash.c iap_protocols.c
  group event_sig
    ../event_manage/src/: mini_dispatch.c uart_debug.c crc.c serial_def_fifo.c p485_fifo.c pT113_fifo.c
  group hardware
    ../Hardware/src/: bsp_init.c serial.c led_beep.c st_crc.c bsp_GeneralTIM.c delay.c gd25q_driver.c dma.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group uart_debug
    ../uart_debug/src/: debug_task.c ex_debug_func.c
software components: CMSIS:CORE 5.4.0
